## boards/shields/adv/Kconfig.shield
```kconfig
config SHIELD_ADV_LEFT
    def_bool $(shields_list_contains,adv_left)

config SHIELD_ADV_RIGHT
    def_bool $(shields_list_contains,adv_right)
```
